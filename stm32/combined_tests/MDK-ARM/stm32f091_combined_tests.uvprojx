# Keil uVision project stm32f091_combined_tests.uvprojx, settings and files
target stm32f091_combined_tests (6070000::V6.7::.\ARMCLANG)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f091_combined_tests
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: ..\src;..\src\stm32f091;..\..\..\hodea-lib;..\..\..\hodea-stm32f0-vpkg\CMSIS\Include;..\..\..\hodea-stm32f0-vpkg\CMSIS\Device\ST\STM32F0xx\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --verbose --list err.txt
  group Source
    ../src/: main.cpp retarget.cpp tfw.cpp
    ../src/basic_functions/: pin_config_test.cpp digio_test.cpp critical_section.cpp
    ../src/stm32f091/: bsp.cpp system_stm32f0xx.cpp
    ../../../hodea-lib/hodea/rte/: setup.cpp
    ../src/stm32f091/arm/: startup_stm32f091xc.s
